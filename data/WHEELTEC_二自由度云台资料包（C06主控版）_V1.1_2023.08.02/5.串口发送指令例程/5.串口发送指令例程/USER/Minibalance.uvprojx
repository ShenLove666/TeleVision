# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\BALANCE\CONTROL;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\show;..\BALANCE\controls;..\..\1.二自由度-180度云台舵机_源码\MiniBalance_HARDWARE\USART3;..\HARDWARE\EXTI;..\HARDWARE\DataScope_DP;..\HARDWARE\CAN;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/USART3/: usart3.c
  group BALANCE
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
